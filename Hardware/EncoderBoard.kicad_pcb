# Repository BlakeGarner/encoders-for-etc-eos

File README.md:

# Encoders for ETC Eos

A 9-encoder (un-official) add on to the [ETC Eos][etceos] Family of Lighting Consoles and Software, using OSC over USB.

This is an independent project that is designed to work with the [ETC Eos][etceos], but not affiliated with Electronic Theatre Controls in any way.

- [Encoders for ETC Eos](#encoders-for-etc-eos)
  - [Quick Start](#quick-start)
  - [Usage](#usage)
    - [Status LEDs](#status-leds)
    - [Page Select Buttons](#page-select-buttons)
    - [Auxilary Buttons](#auxilary-buttons)
  - [Compatibility](#compatibility)
  - [Contributing](#contributing)
  - [Credits](#credits)
  - [License](#license)

## Quick Start

*To build the hardware, consult the README located in the [Hardware](Hardware/README.md) folder.*\
*To make changes to the firmware, consult the README located in the [Firmware](Firmware/README.md) folder.*

1. Connect the encoders to your console, PC or Mac using a USB-A to micro-USB cable.
2. Start up the ETCnomad software or Eos family console.
3. Navigate to Settings > System > Show Control > OSC in the software, and ensure OSC USB is enabled.\
   
4. Reboot the console or restart the software.
5. The left-hand status indicator on the encoders should change from orange (not connected) to green (connected).
6. Select a channel in the Eos console or ETCnomad software, the encoders will update with any parameters applicable to the selected page.
7. Select the page to adjust desired parameters:\
    
   - 1st (red) button: Intensity, focus and beam parameters
   - 2nd (amber) button: Colour parameters (press multiple times to switch between the 3 layouts).
   - 3rd (green) button: Not used - for future use.
   - 4th (blue) button: Framing shutters
8. Adjust parameters by spinning the encoder clockwise or anti-clockwise. A fine mode can be toggled on or off by pushing the encoder in.\

## Usage

The Encoders consist of the following components:

- 9x Encoders each with integrated push-button, a small 10x2 display and RGB LED
- 4x Page-select buttons in red, amber, green and blue.
- 2x Auxilary buttons for future use.
- 3x Auxilary RGB LEDs for status feedback and future use.
- 1x Micro-USB socket for connection to the console, PC or Mac.
- 512kB of memory for future use, such as storing custom user configuration of page layouts.

### Status LEDs

The three RGB LEDs on the right-hand side of the provide some basic functionality feedback:

- The left-hand LED is orange when not connected to any Eos software or console, green when connected.
- The middle LED is not used, reserved for future use.
- The right-hand LED flashes a dim cyan at 1Hz to indicate the encoder firmware is still running its main loop (for debugging purposes).

### Page Select Buttons

The four page select buttons allow the user to choose the group of parameters they wish to adjust:

1. The first (red) button has a single layout for intensity, focus and beam adjustments:\
   
2. The second (amber) button has three layouts for colour adjustments:
   1. CMY Layout:\
      
   2. RGB / x7 Layout:\
      
   3. x7 Adjust Layout:\
      
3. The third (green) button currently has no layout and is for future use.
4. The fourth (blue) button has one layout for framing shutter adjustments:\

### Auxilary Buttons

The two circular buttons on the right hand side are currently not used and reserved for future use.

## Compatibility

The encoders will not work on any Win XPe-based consoles. It should work on any Win 7e-based Eos consoles, as well as any version of the ETCnomad software that supports OSC-over-USB. See the [ETC Lighthack GitHub][lighthack] page:
> Eos supports this functionality on Win7e-based consoles and ETCnomad for Windows in software version 2.6.1 and newer, and on ETCnomad for Mac in software version 2.7.0 and newer.
>
> *Support for XPe-based consoles or XP computers is not planned for this project. Many XPe-based consoles can be upgraded to Win7e to make them compatible with #lighthack.*

As the Lighthack project was intended for the Arduino Uno (and this project uses a Teensy 3.2), the USB Vendor ID and Product ID had to be spoofed so the encoder board looks like an Arduino instead of a Teensy. Eos consoles will ignore OSC messages from USB devices that do not have the Arduino Uno Vendor ID and Product ID.

## Contributing

Contributions are most welcome!
Please log an issue and/or pull request for any bugs or feature changes you may wish to share.

## Credits

[ETC LightHack][lighthack] which formed the basis and initial inspiration for this project

## License

All hardware files (inside `Hardware`) and original source code (inside `Firmware/src`) uses the Apache 2.0 license. See [LICENSE](LICENSE) for more information.

Libraries inside `Firmare/lib` and `Firmware/core` have been licensed separately by their respective authors and include a mixture of BSD, MIT, public domain, LGPLv2 and other licenses. More information on each can be found in the relevant source files.

[lighthack]: https://github.com/ETCLabs/lighthack
[etceos]: https://www.etcconnect.com/Products/Consoles/Eos-Family/

## KiCad design Hardware/EncoderBoard.kicad_pcb

File Hardware/README.md (part):

# Encoders for ETC Eos Hardware

This folder contains all the design files required to build the Encoders for [ETC Eos][etceos] hardware.

The PCB layout and acrylic case aligment was done using [KiCad 5.1][kicad]. The PCB and case was 3D modelled using [FreeCAD v0.18][freecad] and the [KiCAD StepUp plugin][kicad-stepup].

This is an independent project that is designed to work with the [ETC Eos][etceos], but not affiliated with Electronic Theatre Controls in any way.

- [Encoders for ETC Eos Hardware](#encoders-for-etc-eos-hardware)
  - [Installation](#installation)
    - [Step 1: Order PCB, Parts and Acrylic Case](#step-1-order-pcb-parts-and-acrylic-case)
      - [PCB](#pcb)
      - [Electronic Parts](#electronic-parts)
      - [Acrylic Case](#acrylic-case)
      - [Extras](#extras)
    - [Step 2: Assemble the PCB](#step-2-assemble-the-pcb)
    - [Step 3: Fit off the case](#step-3-fit-off-the-case)
    - [Step 4: Upload Firmware](#step-4-upload-firmware)
      - [Using TyTools](#using-tytools)
      - [Using Teensyduino](#using-teensyduino)
    - [Step 5: Test](#step-5-test)
  - [Issues](#issues)
  - [Contributing](#contributing)
  - [Credits](#credits)
  - [License](#license)

## Installation

### Step 1: Order PCB, Parts and Acrylic Case

#### PCB

The schematic and PCB files were built using KiCad 5.1. But you only need the PCB Gerbers located in the `Gerbers` folder to order your PCB. I ordered a black PCB so it matched(-ish) the black of my acrylic case.

#### Electronic Parts

A list of the required components can be found in the BOM folder in either [csv](bom/EncoderBoard_revB.csv) or [xlsx](bom/EncoderBoard_revB.xlsx) format.

- You may need to choose an encoder with a different shaft height than the 20mm I used depending on the internal height of your encoder knobs and space taken up by the acrylic case.
- Don't forget 0.1" headers to solder the Teensy and OLEDs to the PCB.
- Be sure to pay special attention to the component package size on the PCB (and listed in the BOM spreadsheet) when choosing your resistors, capacitors and ICs.
- I sourced most of my components from Digikey or Mouser. You may wish to source the Teensy directly from PJRC (or a distributor) and the WS2812B LEDs and 128x32 OLED displays may be easier and cheaper to source from somewhere like AliExpress. Just be sure the pins are in the same order as the PCB expects!

#### Acrylic Case

The laser-cut acrylic case is quite an expensive solution compared to off-the-shelf enclosures, but it keeps the encoder case slender and elegant.

- The case has five layers:\

  - Layer 1: The top (clear or semi-transparent) layer - 3mm to bring the total height of the case flush with the push buttons.
  - Layer 2: This is the middle layer of the three above-the-PCB layers. It has cutouts only for the components that need to be visible or poke through the top (transparent) layer: encoders, buttons, LEDs, displays and screw holes.
  - Layer 3: This is essentially a spacer between the PCB and layer 2 so none of the electronic components get in the way. It needs to be thicker than the height of your tallest component - 4.5mm was used in the drawings.
  - Layer 4: This is the spacer for your electronic components on the rear side of the board. 4.5mm acrylic was chosen to match that of layer 3.
  - Layer 5: This is a cover plate for the rear side - 2mm was selected to match that of layer 2.
- You should be able to order the acrylic from your local laser-cutter supplier. Make sure the requirements in file format and line colours from your laser cutter matches what is supplied. You can find various files in the `SVG` folder that show the cutouts in a few different layouts.

#### Extras

- Some M2.5 screws that are just the right length for all 5 layers + the PCB (1.6mm usually) + nut. I used screws with a 20mm thread and 3mm thick nuts.
- Some rubber feet that are at least a little deeper than your screw/nut protudes below the case.
- Knobs for the encoders (check the internal height of the encoder will suit the encoder shaft height).
- Button caps for the push buttons.

### Step 2: Assemble the PCB

- Solder all parts **except the OLED displays** to the PCB. I found it easier to do the underside SMT parts first and then the top side SMT parts and finally the PTH parts. The [Interactive HTML BOM page](bom/BOM%20-%20Encoder%20Board,%20Rev%20B.html) in the bom folder should assist when placing components.

  - **DON'T DO THE OLED DISPLAYS YET!** Layer three of the acrylic case needs to go down first.
  - Make sure the Teensy sits within the height of your Layer 3 acrylic (4.5mm).
  - If you've not done SMT soldering before, you may want to practice on a smaller project before attempting this one. SMT soldering is not as hard as it looks but some practice before-hand is advised!
  - Be extra careful with the alignment of the encoders and push buttons when soldering them in place. If they don't line them up perfectly they will likely scrape against the side of the case and not operate correctly.

- Double check all your soldering work - checking for shorts, missing joints or ICs/diodes in the wrong orientation. Even though the OLEDs are not fitted, it is okay to power on the system to check everything else at this point. I used one spare OLED with pogo-pins fitted that I could then use to check each OLED output one-by-one.
- Place Layer 3 of the acrylic case on top of the PCB. Check the sections that will sit under the OLEDs will not force the OLEDs to sit proud of layer 2 - I had to sand those spacers down about one millimeter to reduce the height on the OLEDs. Temporarily hold layer 3 and the PCB together using a few screws.\

- Solder the OLEDs in place, ensuring they will not sit any taller than layer 2 of the acrylic pieces when fitted. Also note that from now on, layer 3 will be fixed in place, and it will no longer be possible to service or re-solder most of the top-mounted SMT components.\

### Step 3: Fit off the case

- Remove any temporary screws holding layer 3 in place, then stack the remaining acrylic layers together and screw the five pieces of acrylic + PCB together. Be gentle when tightening the nuts as the acrylic will crack if placed under stress.\

- Snap the knobs and button caps in place.\

### Step 4: Upload Firmware

- You need TyCommander or Teensyduino to upload the firmware to the Teensy. TyCommander is a simpler install, but Teensyduino is fine if you already have that installed.

#### Using TyTools

- Download [TyTools][tyTools] and extract it somewhere convenient.
- Start up TyCommander.exe
- Plug in the Teensy on the encoder board.
- Place the Teensy board in programming mode by pressing the push-button on top of the Teensy (still accessible using a paperclip with the case in place).
  
- The Teensy should show as in bootloader mode and the upload button should become available. Click the drop-down menu on the upload button and choose "Upload New Firmware".\
  
- Navigate to this project folder and select the `Firmware_x.x.x.hex` file in the `Firmware` folder that matches the version you want to upload (probably the latest version).\
  
- The firmware will take a couple of seconds to upload, and then the board should automatically reboot.

#### Using Teensyduino

- Download the latest Arduino software from the [Arduino website][arduino], and install it.
- Download the latest Teensyduino software from the [PJRC website][teensyduino], and install it.
- Open the Teensy.exe file from the Teensyduino installation directory, or via the Arduino software.
- Click the "Open HEX File" button.\
  
- Navigate to this project folder and select the `Firmware_x.x.x.hex` file in the `Firmware` folder that matches the version you want to upload (probably the latest version).
- Place the Teensy board in programming mode by pressing the push-button on top of the Teensy (still accessible using a paperclip with the case in place).\

Parts:
C1, C3, C5, C7, C9, C10, C72, C73, C74, C75: 0.1uF; C_0805_2012Metric; MPN CL21B104KBCNFNC
C2, C4, C6, C8, C11: 10uF; C_1210_3225Metric; MPN CL32B106KOJNNNE
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R18, R19, R20, R21, R88, R89: 4.7k; R_0805_2012Metric; MPN RC0805FR-074K7L
R17, R96: 150R; R_0805_2012Metric; MPN RC0805FR-07150RL
U1, U2, U3: MCP23S17_SO; SOIC-28W_7.5x17.9mm_P1.27mm; MPN MCP23S17T-E/SO
U4, U6: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm; MPN TCA9548APWR
U5: 74HCT245; TSSOP-20_4.4x6.5mm_P0.65mm; MPN SN74HCT245PWR
U7: Teensy3.2; Teensy30_31_32_LC; MPN TEENSY32
U8, U24, U25, U26: CAT24M01W; SOIC-8_3.9x4.9mm_P1.27mm; MPN CAT24M01WI-GT3

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C72.1, C73.1, C74.1, C75.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R18.1, R19.1, R20.1, R21.1, R88.1, R89.1, U1.9 (VDD), U1.18 (~RESET~), U2.9 (VDD), U2.15 (A0), U2.18 (~RESET~), U3.9 (VDD), U3.16 (A1), U3.18 (~RESET~), U4.24 (VCC), U6.1 (A0), U6.24 (VCC), U7.31 (3.3V_max100mA), U8.8 (VCC), U24.2 (A1), U24.8 (VCC), U25.3 (A2), U25.8 (VCC), U26.2 (A1), U26.3 (A2), U26.8 (VCC); also elsewhere on the board
+5V: C9.1, U5.1 (A->B), U5.20 (VCC), U7.33 (Vin), U7.34 (VUSB); also elsewhere on the board
/WS2812_3V3: U5.2 (A0), U7.3 (1_TX1_Touch)
BUTTON0_LED: U7.7 (5_TX1_PWM); also elsewhere on the board
BUTTON0_SW: U3.7 (GPB6); also elsewhere on the board
BUTTON1_LED: U7.8 (6_PWM); also elsewhere on the board
BUTTON1_SW: U3.8 (GPB7); also elsewhere on the board
BUTTON2_LED: U7.27 (20_A6_CS_PWM); also elsewhere on the board
BUTTON2_SW: U3.24 (GPA3); also elsewhere on the board
BUTTON3_LED: U7.28 (21_A7_RX1_CS_PWM); also elsewhere on the board
BUTTON3_SW: U3.23 (GPA2); also elsewhere on the board
BUTTON4_LED: U7.29 (22_A8_Touch_PWM); also elsewhere on the board
BUTTON4_SW: U3.22 (GPA1); also elsewhere on the board
BUTTON5_LED: U7.30 (23_A9_Touch_PWM); also elsewhere on the board
BUTTON5_SW: U3.21 (GPA0); also elsewhere on the board
CS0: U1.11 (~CS~), U2.11 (~CS~), U3.11 (~CS~), U7.12 (10_TX2_CS_PWM)
EEPROM_WP: U7.4 (2), U8.7 (WP), U24.7 (WP), U25.7 (WP), U26.7 (WP)
ENC0_A: U1.25 (GPA4); also elsewhere on the board
ENC0_B: U1.26 (GPA5); also elsewhere on the board
ENC0_SW: U1.27 (GPA6); also elsewhere on the board
ENC1_A: U1.1 (GPB0); also elsewhere on the board
ENC1_B: U1.2 (GPB1); also elsewhere on the board
ENC1_SW: U1.3 (GPB2); also elsewhere on the board
ENC2_A: U2.25 (GPA4); also elsewhere on the board
ENC2_B: U2.26 (GPA5); also elsewhere on the board
ENC2_SW: U2.27 (GPA6); also elsewhere on the board
ENC3_A: U2.1 (GPB0); also elsewhere on the board
ENC3_B: U2.2 (GPB1); also elsewhere on the board
ENC3_SW: U2.3 (GPB2); also elsewhere on the board
ENC4_A: U1.21 (GPA0); also elsewhere on the board
ENC4_B: U1.22 (GPA1); also elsewhere on the board
ENC4_SW: U1.23 (GPA2); also elsewhere on the board
ENC5_A: U1.5 (GPB4); also elsewhere on the board
ENC5_B: U1.6 (GPB5); also elsewhere on the board
ENC5_SW: U1.7 (GPB6); also elsewhere on the board
ENC6_A: U2.21 (GPA0); also elsewhere on the board
ENC6_B: U2.22 (GPA1); also elsewhere on the board
ENC6_SW: U2.23 (GPA2); also elsewhere on the board
ENC7_A: U2.5 (GPB4); also elsewhere on the board
ENC7_B: U2.6 (GPB5); also elsewhere on the board
ENC7_SW: U2.7 (GPB6); also elsewhere on the board
ENC8_A: U3.25 (GPA4); also elsewhere on the board
ENC8_B: U3.26 (GPA5); also elsewhere on the board
ENC8_SW: U3.27 (GPA6); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C72.2, C73.2, C74.2, C75.2, U1.10 (VSS), U1.15 (A0), U1.16 (A1), U1.17 (A2), U2.10 (VSS), U2.16 (A1), U2.17 (A2), U3.10 (VSS), U3.15 (A0), U3.17 (A2), U4.1 (A0), U4.2 (A1), U4.12 (GND), U4.21 (A2), U5.10 (GND), U5.19 (CE), U6.2 (A1), U6.12 (GND), U6.21 (A2), U7.1 (GND), U7.17 (GND), U7.32 (AGND), U8.2 (A1), U8.3 (A2), U8.4 (GND), U24.3 (A2), U24.4 (GND), U25.2 (A1), U25.4 (GND), U26.4 (GND); also elsewhere on the board
INT0_A: U1.20 (INTA), U7.9 (7_RX3_DOUT)
INT1_A: U2.20 (INTA), U7.10 (8_TX3_DIN)
INT2_A: U3.20 (INTA), U7.11 (9_RX2_CS_PWM)
MISO: U1.14 (SO), U2.14 (SO), U3.14 (SO), U7.14 (12_DIN)
MOSI: U1.13 (SI), U2.13 (SI), U3.13 (SI), U7.13 (11_DOUT)
unnamed: R17.1, R96.2
unnamed: R17.2, U5.18 (B0)
unnamed: R88.2, U4.3 (~RESET)
unnamed: R89.2, U6.3 (~RESET)
SCL: R21.2, U4.22 (SCL), U6.22 (SCL), U7.26 (19_A5_SCL0_Touch), U8.6 (SCL), U24.6 (SCL), U25.6 (SCL), U26.6 (SCL)
SCL0: R1.2, U4.5 (SC0); also elsewhere on the board
SCL1: R3.2, U4.7 (SC1); also elsewhere on the board
SCL2: R5.2, U4.18 (SC6); also elsewhere on the board
SCL3: R7.2, U6.5 (SC0); also elsewhere on the board
SCL4: R9.2, U4.9 (SC2); also elsewhere on the board
SCL5: R11.2, U4.14 (SC4); also elsewhere on the board
SCL6: R13.2, U4.16 (SC5); also elsewhere on the board
SCL7: R15.2, U6.7 (SC1); also elsewhere on the board
SCL8: R18.2, U6.14 (SC4); also elsewhere on the board
SCLK: U1.12 (SCK), U2.12 (SCK), U3.12 (SCK), U7.20 (13_LED_SCK)
SDA: R20.2, U4.23 (SDA), U6.23 (SDA), U7.25 (18_A4_SDA0_Touch), U8.5 (SDA), U24.5 (SDA), U25.5 (SDA), U26.5 (SDA)
SDA0: R2.2, U4.4 (SD0); also elsewhere on the board
SDA1: R4.2, U4.6 (SD1); also elsewhere on the board
SDA2: R6.2, U4.17 (SD6); also elsewhere on the board
SDA3: R8.2, U6.4 (SD0); also elsewhere on the board
SDA4: R10.2, U4.8 (SD2); also elsewhere on the board
SDA5: R12.2, U4.13 (SD4); also elsewhere on the board
SDA6: R14.2, U4.15 (SD5); also elsewhere on the board
SDA7: R16.2, U6.6 (SD1); also elsewhere on the board
SDA8: R19.2, U6.13 (SD4); also elsewhere on the board
WS2812_DATA: R96.1; also elsewhere on the board

Parts:
C12, C13, C16, C17, C21, C22, C23, C24, C29, C42, C43, C44, C48, C49, C50, C51, C55, C56: 0.01uF; C_0805_2012Metric; MPN CL21B103KCANNNC
C14, C15, C18, C19, C20, C25, C26, C27, C28, C45, C46, C47, C52, C53, C54, C57, C58, C59, C60, C61, C62: 0.1uF; C_0805_2012Metric; MPN CL21B104KBCNFNC
R22, R23, R24, R25, R27, R28, R29, R30, R32, R33, R34, R35, R36, R37, R39, R40, R42, R43, R44, R45, R46, R47, R49, R50, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R90, R91, R92, R93, R94, R95: 10k; R_0805_2012Metric; MPN RC0805FR-0710KL
R26, R31, R38, R41, R48, R51: 150R; R_0805_2012Metric; MPN RC0805FR-07150RL
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: Encoder_SW_D12.0xH25.0mm; RotaryEncoder_Bourns_PEC12R-4x20k-Sxxxx-Switch_Vertical_H20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; MPN PEC12R-4025F-S0024-ND
SW10: SW_Push_LED_Red; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BR04;2311402-2
SW11: SW_Push_LED_Blue; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BB04;2311402-4
SW12: SW_Push_LED_Red; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BR04;2311403-2
SW13: SW_Push_LED_Yellow; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BA04;2311403-2
SW14: SW_Push_LED_Green; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BG04;2311403-2
SW15: SW_Push_LED_Blue; TE_Alcoswitch_SPST_LED; MPN FSMIJ63BB04;2311403-2
U18, U19, U20, U21, U22, U23: 74LVC14; SOIC-14_3.9x8.7mm_P1.27mm; MPN SN74LVC14ADR

Connections:
+3V3: C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, R22.1, R23.1, R25.1, R28.1, R30.1, R32.1, R39.1, R40.1, R43.1, R44.1, R45.1, R46.1, R55.1, R56.1, R58.1, R59.1, R60.1, R61.1, R69.1, R70.1, R71.1, R73.1, R74.1, R75.1, R82.1, R83.1, R84.1, R90.1, R91.1, R92.1, R93.1, R94.1, R95.1, U18.14 (3.3V), U19.14 (3.3V), U20.14 (3.3V), U21.14 (3.3V), U22.14 (3.3V), U23.14 (3.3V); also elsewhere on the board
BUTTON0_LED: SW10.A; also elsewhere on the board
BUTTON0_SW: U22.2; also elsewhere on the board
BUTTON1_LED: SW11.A; also elsewhere on the board
BUTTON1_SW: U22.4; also elsewhere on the board
BUTTON2_LED: SW12.A; also elsewhere on the board
BUTTON2_SW: U23.2; also elsewhere on the board
BUTTON3_LED: SW13.A; also elsewhere on the board
BUTTON3_SW: U23.4; also elsewhere on the board
BUTTON4_LED: SW14.A; also elsewhere on the board
BUTTON4_SW: U23.6; also elsewhere on the board
BUTTON5_LED: SW15.A; also elsewhere on the board
BUTTON5_SW: U23.8; also elsewhere on the board
ENC0_A: U18.10; also elsewhere on the board
ENC0_B: U18.8; also elsewhere on the board
ENC0_SW: U18.12; also elsewhere on the board
ENC1_A: U18.6; also elsewhere on the board
ENC1_B: U18.4; also elsewhere on the board
ENC1_SW: U18.2; also elsewhere on the board
ENC2_A: U19.10; also elsewhere on the board
ENC2_B: U19.8; also elsewhere on the board
ENC2_SW: U19.12; also elsewhere on the board
ENC3_A: U19.6; also elsewhere on the board
ENC3_B: U19.4; also elsewhere on the board
ENC3_SW: U19.2; also elsewhere on the board
ENC4_A: U20.10; also elsewhere on the board
ENC4_B: U20.8; also elsewhere on the board
ENC4_SW: U20.12; also elsewhere on the board
ENC5_A: U20.6; also elsewhere on the board
ENC5_B: U20.4; also elsewhere on the board
ENC5_SW: U20.2; also elsewhere on the board
ENC6_A: U21.10; also elsewhere on the board
ENC6_B: U21.8; also elsewhere on the board
ENC6_SW: U21.12; also elsewhere on the board
ENC7_A: U21.6; also elsewhere on the board
ENC7_B: U21.4; also elsewhere on the board
ENC7_SW: U21.2; also elsewhere on the board
ENC8_A: U22.10; also elsewhere on the board
ENC8_B: U22.8; also elsewhere on the board
ENC8_SW: U22.12; also elsewhere on the board
GND: C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, R26.2, R31.2, R38.2, R41.2, R48.2, R51.2, SW1.C, SW1.MP (Mounting_Point), SW1.S2, SW2.C, SW2.MP (Mounting_Point), SW2.S2, SW3.C, SW3.MP (Mounting_Point), SW3.S2, SW4.C, SW4.MP (Mounting_Point), SW4.S2, SW5.C, SW5.MP (Mounting_Point), SW5.S2, SW6.C, SW6.MP (Mounting_Point), SW6.S2, SW7.C, SW7.MP (Mounting_Point), SW7.S2, SW8.C, SW8.MP (Mounting_Point), SW8.S2, SW9.C, SW9.MP (Mounting_Point), SW9.S2, SW10.1, SW10.2, SW11.1, SW11.2, SW12.1, SW12.2, SW13.1, SW13.2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; also elsewhere on the board
unnamed: C12.1, R27.2, U18.11
unnamed: C13.1, R29.2, U18.9
unnamed: C14.1, R33.1, U18.13
unnamed: C15.1, R34.1, U20.1
unnamed: C16.1, R24.2, U20.5
unnamed: C17.1, R35.2, U20.3
unnamed: C18.1, R36.1, U22.1
unnamed: C19.1, R47.1, U18.1
unnamed: C20.1, R49.1, U21.13
unnamed: C21.1, R37.2, U18.5
unnamed: C22.1, R50.2, U18.3
unnamed: C23.1, R42.2, U21.11
unnamed: C24.1, R52.2, U21.9
unnamed: C25.1, R53.1, U22.3
unnamed: C26.1, R62.1, U19.13
unnamed: C27.1, R63.1, U21.1
unnamed: C28.1, R64.1, U23.1
unnamed: C29.1, R54.2, U19.11
unnamed: C42.1, R65.2, U19.9
unnamed: C43.1, R57.2, U21.5
unnamed: C44.1, R66.2, U21.3
unnamed: C45.1, R67.1, U23.3
unnamed: C46.1, R76.1, U19.1
unnamed: C47.1, R77.1, U22.13
unnamed: C48.1, R68.2, U19.5
unnamed: C49.1, R78.2, U19.3
unnamed: C50.1, R72.2, U22.11
unnamed: C51.1, R79.2, U22.9
unnamed: C52.1, R80.1, U23.5
unnamed: C53.1, R85.1, U20.13
unnamed: C54.1, R86.1, U23.9
unnamed: C55.1, R81.2, U20.11
unnamed: C56.1, R87.2, U20.9
unnamed: R22.2, R27.1, SW1.A
unnamed: R23.2, R29.1, SW1.B
unnamed: R24.1, R25.2, SW6.A
unnamed: R26.1, SW10.K
unnamed: R28.2, R35.1, SW6.B
unnamed: R30.2, R33.2, SW1.S1
unnamed: R31.1, SW11.K
unnamed: R32.2, R34.2, SW6.S1
unnamed: R36.2, R90.2, SW10.3, SW10.4
unnamed: R37.1, R39.2, SW2.A
unnamed: R38.1, SW12.K
unnamed: R40.2, R50.1, SW2.B
unnamed: R41.1, SW13.K
unnamed: R42.1, R43.2, SW7.A
unnamed: R44.2, R52.1, SW7.B
unnamed: R45.2, R47.2, SW2.S1
unnamed: R46.2, R49.2, SW7.S1
unnamed: R48.1, SW14.K
unnamed: R51.1, SW15.K
unnamed: R53.2, R91.2, SW11.3, SW11.4
unnamed: R54.1, R55.2, SW3.A
unnamed: R56.2, R65.1, SW3.B
unnamed: R57.1, R58.2, SW8.A
unnamed: R59.2, R66.1, SW8.B
unnamed: R60.2, R62.2, SW3.S1
unnamed: R61.2, R63.2, SW8.S1
unnamed: R64.2, R92.2, SW12.3, SW12.4
unnamed: R67.2, R93.2, SW13.3, SW13.4
unnamed: R68.1, R69.2, SW4.A
unnamed: R70.2, R78.1, SW4.B
unnamed: R71.2, R76.2, SW4.S1
unnamed: R72.1, R73.2, SW9.A
unnamed: R74.2, R79.1, SW9.B
unnamed: R75.2, R77.2, SW9.S1
unnamed: R80.2, R94.2, SW14.3, SW14.4
unnamed: R81.1, R82.2, SW5.A
unnamed: R83.2, R87.1, SW5.B
unnamed: R84.2, R85.2, SW5.S1
unnamed: R86.2, R95.2, SW15.3, SW15.4

Parts:
C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C63, C64, C65, C66, C67, C68, C69, C70, C71: 0.1uF; C_0805_2012Metric; MPN CL21B104KBCNFNC
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; MPN WS2812B
U9, U10, U11, U12, U13, U14, U15, U16, U17: Display_OLED_128x32_I2C; MPN SSD1306_I2C_128x32_OLED

Connections:
+3V3: C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, U9.3 (VCC), U10.3 (VCC), U11.3 (VCC), U12.3 (VCC), U13.3 (VCC), U14.3 (VCC), U15.3 (VCC), U16.3 (VCC), U17.3 (VCC); also elsewhere on the board
+5V: C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD); also elsewhere on the board
GND: C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), U9.4 (GND), U10.4 (GND), U11.4 (GND), U12.4 (GND), U13.4 (GND), U14.4 (GND), U15.4 (GND), U16.4 (GND), U17.4 (GND); also elsewhere on the board
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: D9.2 (DOUT), D10.4 (DIN)
unnamed: D11.2 (DOUT), D12.4 (DIN)
SCL0: U9.2 (SCL); also elsewhere on the board
SCL1: U10.2 (SCL); also elsewhere on the board
SCL2: U11.2 (SCL); also elsewhere on the board
SCL3: U12.2 (SCL); also elsewhere on the board
SCL4: U13.2 (SCL); also elsewhere on the board
SCL5: U14.2 (SCL); also elsewhere on the board
SCL6: U15.2 (SCL); also elsewhere on the board
SCL7: U16.2 (SCL); also elsewhere on the board
SCL8: U17.2 (SCL); also elsewhere on the board
SDA0: U9.1 (SDA); also elsewhere on the board
SDA1: U10.1 (SDA); also elsewhere on the board
SDA2: U11.1 (SDA); also elsewhere on the board
SDA3: U12.1 (SDA); also elsewhere on the board
SDA4: U13.1 (SDA); also elsewhere on the board
SDA5: U14.1 (SDA); also elsewhere on the board
SDA6: U15.1 (SDA); also elsewhere on the board
SDA7: U16.1 (SDA); also elsewhere on the board
SDA8: U17.1 (SDA); also elsewhere on the board
WS2812_DATA: D1.4 (DIN); also elsewhere on the board
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

Notices in the files:
Hardware/README.md:
License:
All hardware files (inside `EncoderBoard`) uses the Apache 2.0 license. See [LICENSE](../LICENSE) for more information.
