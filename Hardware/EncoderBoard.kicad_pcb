# Repository BlakeGarner/encoders-for-etc-eos (continued)

## KiCad design Hardware/EncoderBoard.kicad_pcb (continued)

Board: 2 copper layers, 231.5 x 65.0 mm, 224 parts (168 on the bottom side), 159 nets.

File Hardware/bom/BOM_EncoderBoard_RevC_Dev.csv (part):

Reference, Value, Footprint, Datasheet, MFR, MPN
"U7","Teensy3.2","Teensy_BG:Teensy30_31_32_LC","https://www.pjrc.com/store/teensy32.html","PJRC","TEENSY32"
"U1","MCP23S17_SO","SOIC_BG:SOIC-28W_7.5x17.9mm_P1.27mm","http://ww1.microchip.com/downloads/en/DeviceDoc/20001952C.pdf","Microchip","MCP23S17T-E/SO"
"U2","MCP23S17_SO","SOIC_BG:SOIC-28W_7.5x17.9mm_P1.27mm","http://ww1.microchip.com/downloads/en/DeviceDoc/20001952C.pdf","Microchip","MCP23S17T-E/SO"
"U3","MCP23S17_SO","SOIC_BG:SOIC-28W_7.5x17.9mm_P1.27mm","http://ww1.microchip.com/downloads/en/DeviceDoc/20001952C.pdf","Microchip","MCP23S17T-E/SO"
"R1","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R2","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R3","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R4","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R5","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R6","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R7","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R8","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R9","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R10","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R11","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R12","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R13","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R14","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R15","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R16","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"U4","TCA9548APWR","TSSOP_BG:TSSOP-24_4.4x7.8mm_P0.65mm","http://www.ti.com/lit/ds/symlink/tca9548a.pdf","Texas Instruments","TCA9548APWR"
"R18","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R19","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"C11","10uF","Capacitor_BG:C_1210_3225Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL32B106KOJNNNE"
"C10","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C8","10uF","Capacitor_BG:C_1210_3225Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL32B106KOJNNNE"
"C7","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"R21","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R20","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"C6","10uF","Capacitor_BG:C_1210_3225Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL32B106KOJNNNE"
"C5","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C4","10uF","Capacitor_BG:C_1210_3225Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL32B106KOJNNNE"
"C3","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C2","10uF","Capacitor_BG:C_1210_3225Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL32B106KOJNNNE"
"C1","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"U5","74HCT245","TSSOP_BG:TSSOP-20_4.4x6.5mm_P0.65mm","http://www.ti.com/lit/gpn/sn74HC245","Texas Instruments","SN74HCT245DWR"
"R17","330R","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-07330RL"
"C9","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"U8","CAT24M01W","SOIC_BG:SOIC-8_3.9x4.9mm_P1.27mm","https://www.onsemi.com/pub/Collateral/CAT24M01-D.PDF","ON Semiconductor","CAT24M01WI-GT3"
"U25","CAT24M01W","SOIC_BG:SOIC-8_3.9x4.9mm_P1.27mm","https://www.onsemi.com/pub/Collateral/CAT24M01-D.PDF","ON Semiconductor","CAT24M01WI-GT3"
"U24","CAT24M01W","SOIC_BG:SOIC-8_3.9x4.9mm_P1.27mm","https://www.onsemi.com/pub/Collateral/CAT24M01-D.PDF","ON Semiconductor","CAT24M01WI-GT3"
"U26","CAT24M01W","SOIC_BG:SOIC-8_3.9x4.9mm_P1.27mm","https://www.onsemi.com/pub/Collateral/CAT24M01-D.PDF","ON Semiconductor","CAT24M01WI-GT3"
"U6","TCA9548APWR","TSSOP_BG:TSSOP-24_4.4x7.8mm_P0.65mm","http://www.ti.com/lit/ds/symlink/tca9548a.pdf","Texas Instruments","TCA9548APWR"
"R89","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"R88","4.7k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-074K7L"
"C74","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C72","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C73","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"C75","0.1uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B104KBCNFNC"
"SW1","Encoder_SW_D12.0xH25.0mm","Encoder_BG:RotaryEncoder_Bourns_PEC12R-4x20k-Sxxxx-Switch_Vertical_H20mm","https://www.bourns.com/docs/Product-Datasheets/PEC12R.pdf","Bourns","PEC12R-4025F-S0024-ND"
"R27","10k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-0710KL"
"R29","10k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-0710KL"
"R22","10k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-0710KL"
"R23","10k","Resistor_BG:R_0805_2012Metric","https://www.yageo.com/upload/media/product/productsearch/dat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","Yageo","RC0805FR-0710KL"
"C13","0.01uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B103KCANNNC"
"C12","0.01uF","Capacitor_BG:C_0805_2012Metric","https://media.digikey.com/pdf/Data%20Sheets/Samsung%20PDFs/C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","Samsung","CL21B103KCANNNC"
"SW2","Encoder_SW_D12.0xH25.0mm","Encoder_BG:RotaryEncoder_Bourns_PEC12R-4x20k-Sxxxx-Switch_Vertical_H20mm","https://www.bourns.com/docs/Product-Datasheets/PEC12R.pdf","Bourns","PEC12R-4025F-S0024-ND"
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
## Commit log

2019-06-01 Added initial KiCad project for board.
2019-06-01 Drew first revision of circuit schematic.
    This is prior to any tests / prototyping.
2019-06-02 Updated all switches to LED. Added EEPROM. Added rough costing.
    Decided all switches could be LED (I can work out the colours later).
    The EEPROM is a 1Mb model - might come in handy later.
    Rough Costs was just to get a decent sense of how much this project will actually cost. Thankfully I already have some Pis...
2019-06-02 Updated embedded library.
2019-06-10 Updated schematic with appropriate symbols and latest library.
2019-06-12 Generated draft footprint PCB with (very) approximate placements.
2019-07-10 Tidied up the encoder board, updated debounce logic for schematic.
2019-07-11 Completed final drafting of Encoder Board.
    Not quite submitted yet - but pretty close to the final layout for the board to be made.
2019-07-12 Further improvements to PCB layout.
    Fixed up silkscreen layout.
2019-07-15 Final version of Rev A board.
    - Fixed up address pins on some chips.
    - Added some additional bypass capacitors.
    - Fixed up some broken footprint references.
    - Some minor layout adjustments.
2019-07-23 Small changes.
2019-07-26 First Draft of acrylic case stencils
2019-07-26 Second Draft of acrylic case.
2019-07-27 Redo of SVGs as something was weird in the last lot (scaling was out by 0.1mm).
2019-08-21 Final revision of Rev A Board + Acrylic Case
2020-06-02 v1.0.0 build of project.
    Added LICENSE, NOTICE file. Add README to firmware folder.
    Adjusted VID and PID to mimic Arduino Uno.
    Ported entire arduino project to pure cpp program in VS Code.
2020-06-02 Some changes to hyperlinks in EncoderBoard README.
2020-06-02 Cleaned up a few hardware files, added more hardware todos.
2020-06-02 Proof read of firmware README
2020-06-02 Small fixes - including cleanup of VERSION macro.
2020-06-02 Added main README.md
2020-06-02 Added README for EncoderBoard folder.
2020-06-02 Renamed EncoderBoard folder to Hardware
2020-06-02 Fixed up LICENSE link in hardware README.
2020-06-02 Removed out-of-date Rough Parts Cost.xlsx and Height Stackup.xlsx.
    You can find the most current BOM in the bom folder.
2020-06-02 Fixed missing pull-up resistors and published RevB of PCB.
2020-06-02 Updated sheet rev numbers
2020-06-03 Applied MPN to each item and consolidated some parts
2020-06-03 Substituted buttons as digikey is discontinuing the old ones.
    Still need to update their footprints.
2020-06-03 Updated schematic and BOM spreadsheets with Manufacturer and Part Numbers
2020-06-11 Finished (untested) sketch of the Rev C PCB.
    TODO: Revise svg, 3D model and PDFs of the acrylic.
2020-06-16 Fixed incorrect package in SN74HCT245. Should have been TSSOP instead of SOIP.
2020-06-18 Added Rev C BOM and first draft of acrylic cut-outs
2020-09-03 Updated acrylic cutouts for encoder board hardware
2020-09-03 Revised case acrylic cutouts
2020-09-09 Tiny fix to board - widen anode drill hole for LED pushbuttons.
    (The red LED has an 0.8mm anode / 0.6mm cathode, while all other colours are the other way around.
    To simplify things, I've now just made them all 0.8mm - so user has to double check orientation).
    No change to PCB rev letter, but date changed on silkscreen.
2022-10-10 Update to kicad library.
