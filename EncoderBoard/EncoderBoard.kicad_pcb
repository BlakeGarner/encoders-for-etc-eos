File: EncoderBoard/EncoderBoard.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: Generated draft footprint PCB with (very) approximate placements.
Parts:
- added C1: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (172.2, -37.1)
- added C10: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (164.0, -34.1)
- added C11: 10uF, Capacitor_BG:C_1210_3225Metric, F.Cu at (213.4, -35.6)
- added C12: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (67.7, -152.1)
- added C13: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (58.9, -149.1)
- added C14: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (77.4, -142.3)
- added C15: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (63.3, -152.1)
- added C16: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (108.0, -154.5)
- added C17: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (103.6, -151.6)
- added C18: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (48.2, -135.6)
- added C19: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (58.9, -146.2)
- added C2: 10uF, Capacitor_BG:C_1210_3225Metric, F.Cu at (227.8, -34.2)
- added C20: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (81.8, -148.2)
- added C21: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (103.6, -148.6)
- added C22: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (77.4, -145.3)
- added C23: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (52.6, -135.6)
- added C24: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (108.0, -151.6)
- added C25: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (26.2, -135.6)
- added C26: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (103.6, -154.5)
- added C27: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (43.8, -135.6)
- added C28: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (77.4, -148.2)
- added C29: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (39.4, -135.6)
- added C3: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (192.6, -34.8)
- added C30: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (152.3, -151.6)
- added C31: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (147.8, -151.6)
- added C32: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (143.4, -151.6)
- added C33: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (139.0, -151.6)
- added C34: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (134.6, -151.6)
- added C35: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (152.7, -154.5)
- added C36: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (126.2, -147.9)
- added C37: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (148.2, -154.5)
- added C38: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (143.8, -154.5)
- added C39: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (139.4, -154.5)
- added C4: 10uF, Capacitor_BG:C_1210_3225Metric, F.Cu at (188.2, -31.8)
- added C40: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (135.0, -154.5)
- added C41: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (130.6, -147.9)
- added C5: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (279.3, -62.3)
- added C6: 10uF, Capacitor_BG:C_1210_3225Metric, F.Cu at (188.2, -34.8)
- added C7: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (159.6, -34.1)
- added C8: 10uF, Capacitor_BG:C_1210_3225Metric, F.Cu at (146.4, -34.1)
- added C9: 100nF, Capacitor_BG:C_0805_2012Metric, F.Cu at (227.8, -40.1)
- added D1: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (63.5, -101.6)
- added D10: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (248.9, -86.4)
- added D11: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (274.3, -86.4)
- added D12: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (261.6, -86.4)
- added D2: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (114.3, -101.6)
- added D3: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (165.1, -101.6)
- added D4: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (215.9, -101.6)
- added D5: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (63.5, -66.0)
- added D6: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (114.3, -66.0)
- added D7: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (165.1, -66.0)
- added D8: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (215.9, -66.0)
- added D9: WS2812B, LED_BG:LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm, F.Cu at (266.7, -66.0)
- added R1: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (188.3, -28.9)
- added R10: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (168.5, -34.1)
- added R11: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (180.7, -41.2)
- added R12: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (172.9, -34.1)
- added R13: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (192.7, -28.9)
- added R14: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (283.7, -59.3)
- added R15: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (279.3, -56.4)
- added R16: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (201.4, -37.7)
- added R17: 330R, Resistor_BG:R_0805_2012Metric, F.Cu at (232.2, -37.2)
- added R18: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (279.8, -53.4)
- added R19: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (188.2, -37.7)
- added R2: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (279.3, -59.3)
- added R20: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (150.8, -34.1)
- added R21: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (155.2, -34.1)
- added R22: 10k, Resistor_BG:R_0805_2012Metric, F.Cu at (81.8, -145.3)
- added R23: 10k, Resistor_BG:R_0805_2012Metric, F.Cu at (58.9, -143.2)
- added R24: 10k, Resistor_BG:R_0805_2012Metric, F.Cu at (86.2, -148.2)
- added R25: 10k, Resistor_BG:R_0805_2012Metric, F.Cu at (21.8, -135.6)
- added R26: 120, Resistor_BG:R_0805_2012Metric, F.Cu at (63.3, -146.2)
- added R27: 1k, Resistor_BG:R_0805_2012Metric, F.Cu at (90.7, -148.2)
- added R28: 1k, Resistor_BG:R_0805_2012Metric, F.Cu at (112.4, -154.5)
- added R29: 1k, Resistor_BG:R_0805_2012Metric, F.Cu at (58.9, -140.3)
- added R3: 4.7k, Resistor_BG:R_0805_2012Metric, F.Cu at (197.0, -37.7)
- added R30: 1k, Resistor_BG:R_0805_2012Metric, F.Cu at (81.8, -142.3)
- added R31: 68, Resistor_BG:R_0805_2012Metric, F.Cu at (67.7, -149.1)
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
Commit message: Tidied up the encoder board, updated debounce logic for schematic.
Parts:
- added REF**: M3, MountingHole:MountingHole_3.2mm_M3, F.Cu at (126.0, 6.00)
- added REF**: M3, MountingHole:MountingHole_3.2mm_M3, F.Cu at (126.0, 36.0)
- added REF**: M3, MountingHole:MountingHole_3.2mm_M3, F.Cu at (204.0, 36.0)
- added REF**: M3, MountingHole:MountingHole_3.2mm_M3, F.Cu at (18.0, 36.0)
- added REF**: M3, MountingHole:MountingHole_3.2mm_M3, F.Cu at (18.0, 6.00)
- moved C2 202.0 mm to (34.9, 26.0), turned to 270 degrees
- moved R36 181.1 mm to (67.3, 19.7), turned to 180 degrees
- moved C16 180.3 mm to (64.1, 20.3), turned to 270 degrees
- moved R27 179.0 mm to (28.6, 19.7), turned to 180 degrees
- moved C12 177.5 mm to (25.4, 20.3), turned to 270 degrees
- moved R22 175.2 mm to (28.6, 21.6)
- moved C17 173.9 mm to (77.5, 20.3), turned to 270 degrees
- moved R32 173.7 mm to (67.3, 21.6)
- moved R39 171.6 mm to (74.3, 19.7)
- moved C13 171.4 mm to (37.5, 21.0), turned to 270 degrees
- moved U5 170.7 mm to (160.7, 51.4)
- moved R33 169.8 mm to (74.3, 21.6), turned to 180 degrees
- moved R23 166.7 mm to (34.3, 21.6), turned to 180 degrees
- moved R29 161.9 mm to (34.3, 19.7)
- moved U8 160.9 mm to (196.8, 51.4)
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Routing:
- net (no net): vias 0 -> 1
Other:
- board outline added: 210 x 61 mm

Commit message: Completed final drafting of Encoder Board.
Not quite submitted yet - but pretty close to the final layout for the board to be made.
Parts:
- removed the REF** at (126.0, 6.00)
- removed the REF** at (126.0, 36.0)
- removed the REF** at (204.0, 36.0)
- removed the REF** at (18.0, 36.0)
- removed the REF** at (18.0, 6.00)
- added C42: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (102.5, 15.0)
- added C43: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (139.5, 42.5)
- added C44: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (141.5, 42.5)
- added C45: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (15.5, 22.5)
- added C46: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (138.0, 6.50)
- added C47: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (177.0, 35.0)
- added C48: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (139.5, 14.5)
- added C49: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (141.5, 14.5)
- added C50: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (178.5, 42.5)
- added C51: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (180.5, 42.5)
- added C52: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (14.5, 45.0)
- added C53: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (21.0, 34.5)
- added C54: 0.1uF, Capacitor_BG:C_0805_2012Metric, F.Cu at (8.25, 58.0)
- added C55: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (22.5, 42.5)
- added C56: 0.01uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (24.5, 42.5)
- added C57: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (42.0, 4.00)
- added C58: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (120.0, 4.00)
- added C59: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (40.0, 35.0)
- added C60: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (118.0, 35.0)
- added C61: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (191.0, 32.5)
- added C62: 0.1uF, Capacitor_BG:C_0805_2012Metric, B.Cu at (201.0, 48.5)
- added C63: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (28.5, 27.0)
- added C64: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (67.5, 27.0)
- added C65: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (106.5, 27.0)
- added C66: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (145.5, 27.0)
- added C67: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (28.5, 55.0)
- added C68: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (67.5, 55.0)
- added C69: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (106.5, 55.0)
- added C70: 100nF, Capacitor_BG:C_0805_2012Metric, B.Cu at (145.5, 55.0)
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Connections:
- C12 pad 1: ENC0_A -> Net-(C12-Pad1)
- C13 pad 1: ENC0_B -> Net-(C13-Pad1)
- C14 pad 1: ENC5_A -> Net-(C14-Pad1)
- C15 pad 1: ENC5_B -> Net-(C15-Pad1)
- C16 pad 1: ENC1_A -> Net-(C16-Pad1)
- C17 pad 1: ENC1_B -> Net-(C17-Pad1)
- C18 pad 1: ENC6_A -> Net-(C18-Pad1)
- C19 pad 1: ENC6_B -> Net-(C19-Pad1)
- C20 pad 1: ENC2_A -> Net-(C20-Pad1)
- C21 pad 1: ENC2_B -> Net-(C21-Pad1)
- C22 pad 1: ENC7_A -> Net-(C22-Pad1)
- C23 pad 1: ENC7_B -> Net-(C23-Pad1)
- C24 pad 1: ENC3_A -> Net-(C24-Pad1)
- C25 pad 1: ENC3_B -> Net-(C25-Pad1)
- C26 pad 1: ENC8_A -> Net-(C26-Pad1)
- C27 pad 1: ENC8_B -> Net-(C27-Pad1)
- C28 pad 1: ENC4_A -> Net-(C28-Pad1)
- C29 pad 1: ENC4_B -> Net-(C29-Pad1)
- R24 pad 1: +3V3 -> Net-(R24-Pad1)
- R24 pad 2: Net-(R24-Pad2) -> Net-(C16-Pad1)
- R25 pad 2: Net-(R25-Pad2) -> Net-(R24-Pad1)
- R27 pad 2: ENC0_A -> Net-(C12-Pad1)
- R28 pad 1: Net-(R24-Pad2) -> +3V3
- R28 pad 2: ENC5_A -> Net-(R28-Pad2)
- R29 pad 2: ENC0_B -> Net-(C13-Pad1)
- R30 pad 1: Net-(R25-Pad2) -> +3V3
- R30 pad 2: ENC5_B -> Net-(R30-Pad2)
- R33 pad 1: +3V3 -> Net-(C14-Pad1)
- R33 pad 2: Net-(R33-Pad2) -> Net-(R30-Pad2)
- R34 pad 1: +3V3 -> Net-(C15-Pad1)
- R34 pad 2: Net-(R34-Pad2) -> Net-(R32-Pad2)
- R35 pad 1: +3V3 -> Net-(R28-Pad2)
- R35 pad 2: Net-(R35-Pad2) -> Net-(C17-Pad1)
- R36 pad 1: Net-(R32-Pad2) -> Net-(C18-Pad1)
- R36 pad 2: ENC1_A -> Net-(R36-Pad2)
- R37 pad 1: Net-(R34-Pad2) -> Net-(R37-Pad1)
- R37 pad 2: ENC6_A -> Net-(C21-Pad1)
- R39 pad 1: Net-(R33-Pad2) -> +3V3
- R39 pad 2: ENC1_B -> Net-(R37-Pad1)
- R40 pad 1: Net-(R35-Pad2) -> +3V3
- R40 pad 2: ENC6_B -> Net-(R40-Pad2)
- R42 pad 1: +3V3 -> Net-(R42-Pad1)
- R42 pad 2: Net-(R42-Pad2) -> Net-(C23-Pad1)
- R43 pad 2: Net-(R43-Pad2) -> Net-(R42-Pad1)
- R46 pad 1: Net-(R42-Pad2) -> +3V3
- R46 pad 2: ENC2_A -> Net-(R46-Pad2)
- R47 pad 1: Net-(R44-Pad2) -> Net-(C19-Pad1)
- R47 pad 2: ENC7_A -> Net-(R45-Pad2)
- R49 pad 1: Net-(R43-Pad2) -> Net-(C20-Pad1)
- R49 pad 2: ENC2_B -> Net-(R46-Pad2)
- R50 pad 1: Net-(R45-Pad2) -> Net-(R40-Pad2)
- R50 pad 2: ENC7_B -> Net-(C22-Pad1)
- R52 pad 1: +3V3 -> Net-(R44-Pad2)
- R52 pad 2: Net-(R52-Pad2) -> Net-(C24-Pad1)
- R53 pad 1: +3V3 -> Net-(C25-Pad1)
- R54 pad 1: +3V3 -> Net-(R54-Pad1)
- R54 pad 2: Net-(R54-Pad2) -> Net-(C29-Pad1)
- R55 pad 2: Net-(R55-Pad2) -> Net-(R54-Pad1)
- R56 pad 1: Net-(R52-Pad2) -> +3V3
- R56 pad 2: ENC3_A -> Net-(R56-Pad2)
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Routing:
- net +3V3: track 0.00 -> 1013.4 mm, vias 0 -> 13
- net GND: track 0.00 -> 681.9 mm, vias 0 -> 37
- net +5V: track 0.00 -> 567.3 mm, vias 0 -> 6
- net BUTTON5_LED: track 0.00 -> 268.5 mm
- net BUTTON4_LED: track 0.00 -> 250.2 mm
- net Net-(C28-Pad1): track 0.00 -> 243.2 mm, vias 0 -> 1
- net Net-(C45-Pad1): track 0.00 -> 242.1 mm, vias 0 -> 1
- net BUTTON3_LED: track 0.00 -> 232.4 mm
- net BUTTON2_LED: track 0.00 -> 223.4 mm
- net SCLK: track 0.00 -> 220.1 mm, vias 0 -> 4
- net MISO: track 0.00 -> 210.0 mm, vias 0 -> 5
- net CS0: track 0.00 -> 209.8 mm, vias 0 -> 5
- net Net-(C52-Pad1): track 0.00 -> 208.9 mm, vias 0 -> 1
- net MOSI: track 0.00 -> 208.6 mm, vias 0 -> 5
- net Net-(C54-Pad1): track 0.00 -> 197.6 mm, vias 0 -> 1
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- added copper zone on B.Cu, net GND
Other:
- board size 210 x 61 mm -> 221 x 61 mm
- net class Default: clearance 0.2 -> 0.1524; trace_width 0.25 -> 0.3048; via_dia 0.8 -> 0.762; via_drill 0.4 -> 0.381
- net class Power_3V3 added: clearance 0.1524, trace_width 0.762, via_dia 1.524, via_drill 0.762
- net class Power_5V added: clearance 0.1524, trace_width 1.016, via_dia 1.524, via_drill 0.762
- rule trace_clearance: 0.2 -> 0.1524
- rule trace_min: 0.2 -> 0.254
- rule via_min_drill: 0.3 -> 0.3048
- rule via_min_size: 0.4 -> 0.508

Commit message: Further improvements to PCB layout.
Fixed up silkscreen layout.
Parts:
- moved SW11 0.29 mm to (177.5, 9.00)
Routing:
- net +3V3: track 1013.4 -> 984.3 mm, vias 13 -> 19
- net SCLK: track 220.1 -> 194.4 mm, vias 4 -> 7
- net GND: track 681.9 -> 706.4 mm, vias 37 -> 36
- net Net-(C14-Pad1): track 31.4 -> 20.8 mm
- net INT0_A: track 188.3 -> 180.7 mm
- net MISO: track 210.0 -> 213.0 mm
- net EEPROM_WP: track 99.7 -> 101.5 mm, vias 0 -> 2
- net Net-(C49-Pad1): track 23.6 -> 22.6 mm
- net INT1_A: track 102.3 -> 101.4 mm
- net BUTTON4_LED: track 250.2 -> 249.4 mm
- net BUTTON5_LED: track 268.5 -> 267.6 mm
- net SDA4: track 73.1 -> 73.9 mm
- net MOSI: track 208.6 -> 209.2 mm
- net SDA3: track 31.2 -> 30.6 mm
- net BUTTON5_SW: track 23.3 -> 23.8 mm
